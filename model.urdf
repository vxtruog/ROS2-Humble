Commit message: Update model.urdf

File: model.urdf (robot description, URDF)
Before this commit: robot simple_robot, 3 links, 2 joints
Joints:
- joint joint_2: axis 0 1 0 -> 0 0 1
